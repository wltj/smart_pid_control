# Keil uVision project modbus_51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: modbus_51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c modbus.c debugUart.c eeprom.c crc.c adc_sensor.c uart_adc.c
